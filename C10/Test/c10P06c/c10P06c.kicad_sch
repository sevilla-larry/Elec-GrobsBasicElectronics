File: C10/Test/c10P06c/c10P06c.kicad_sch (KiCad schematic)
At the start: 3 parts

Commit message: additional and moved files Chapter 10
Parts:
- removed Rl3: 12, symbol Device:R
